# Keil uVision project NP801.uvproj, settings and files
target NP801 (ARM-ADS)
  device: STM32F103RF STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80BFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: NP801 +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xG
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Middlewares\STemWin\Config;..\Middlewares\STemWin\inc;..\Src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f1xx_it.c stm32f1xx_hal_msp.c main.c LCD_MD070SD.c guiTask.c XPT2046.c TOUCH_Calibrate.c lookUp.c tempTab.c filter.c Window.c side.c graphDLG.c keyboard.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_tim_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal.c stm32f1xx_hal_crc.c stm32f1xx_hal_tim.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group STemWin/Config
    ../Middlewares/STemWin/Config/: GUIConf.c GUIDRV_Template.c LCDConf.c GUI_X_Touch.c
    ../Middlewares/STemWin/OS/: GUI_X.c
  group STemWin/Lib
    ../Middlewares/STemWin/Lib/: STemWin528_CM3_Keil.lib
