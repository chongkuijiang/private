# Keil uVision project LeakAdhesiveSensor.uvproj, settings and files
target LeakAdhesiveSensor (ARM-ADS)
  device: STM32F103RF STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80BFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LeakAdhesiveSensor +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F10X_XL, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\Middlewares\STemWin\inc;..\..\Middlewares\STemWin\Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_xl.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c bsp_adc.c graphDLG.c guiTask.c keyboard.c LCD_MD070SD.c lookUp.c tempTab.c TOUCH_Calibrate.c XPT2046.c AT24CXX.c SetOfsDLG.c skin.c
  group STemWin/Lib
    ../../Middlewares/STemWin/Lib/: STemWin528_CM3_Keil.lib
  group STemWin/Config
    ../../Middlewares/STemWin/Config/: GUI_X_Touch.c GUIConf.c GUIDRV_Template.c LCDConf.c
    ../../Middlewares/STemWin/OS/: GUI_X.c
